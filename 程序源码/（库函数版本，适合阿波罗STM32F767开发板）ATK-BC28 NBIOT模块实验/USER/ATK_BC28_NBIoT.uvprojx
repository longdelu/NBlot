# Keil uVision project ATK_BC28_NBIoT.uvprojx, settings and files
target ATK_BC28_NBIOT (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F767IGTx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.10.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x100000) IROM2(0x00200000,0x100000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: NBIoT +hex
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F767xx,USE_HAL_DRIVER
  c include: ..\CORE;..\OBJ;..\USER;..\HALLIB\STM32F7xx_HAL_Driver\Inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\SDRAM;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\HARDWARE\PCF8574;..\HARDWARE\DHT11;..\USMART;..\HARDWARE\DS18B20;..\HARDWARE\BEEP;..\HARDWARE\AP3216C;..\HARDWARE\BEEP;..\ATK_RING_BUF;..\EXAMPLE;..\HARDWARE\NBIOT_UART;..\ATK_SOFT_TIMER;..\HARDWARE\ATK-BC28;..\HARDWARE\RGB_LED;..\HARDWARE\TIMER
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x200000 size 0x100000
  memory RVCT9: RAM 0x20020000 size 0x60000
  memory RVCT10: RAM 0x20000000 size 0x20000
  group USER
    ./: main.c stm32f7xx_it.c system_stm32f7xx.c
  group CORE
    ../CORE/: core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f767xx.s
  group HALLIB
    ../HALLIB/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_ll_fmc.c stm32f7xx_hal_sram.c stm32f7xx_hal_sdram.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_can.c
  group SYSTEM
    ../SYSTEM/sys/: atk_sys.c
    ../SYSTEM/delay/: atk_delay.c
    ../SYSTEM/usart/: atk_usart.c
  group HARDWARE
    ../HARDWARE/SDRAM/: sdram.c
    ../HARDWARE/LCD/: lcd.c ltdc.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/PCF8574/: pcf8574.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/NBIOT_UART/: atk_nbiot_usart.c
    ../HARDWARE/BEEP/: atk_beep.c
    ../HARDWARE/AP3216C/: ap3216c.c
    ../HARDWARE/DS18B20/: ds18b20.c
    ../HARDWARE/LED/: atk_led.c
    ../HARDWARE/KEY/: atk_key.c
    ../HARDWARE/TIMER/: atk_timer.c
    ../HARDWARE/RGB_LED/: atk_rgb_led.c
  group ATKBC28
    ../HARDWARE/ATK-BC28/: atk_bc28.c atk_bc28_nbiot.c
  group SOFTTIMER
    ../ATK_SOFT_TIMER/: atk_soft_timer.c
  group RINGBUF
    ../ATK_RING_BUF/: atk_ring_buf.c
  group EXAMPLE
    ../EXAMPLE/ap3216c/: demo_ap3216c_entry.c
    ../EXAMPLE/atk_nbiot_bc28/: demo_bc28_net_attach_entry.c demo_bc28_low_power_entry.c demo_bc28_huaweiiot_entry.c demo_bc28_info.c
    ../EXAMPLE/dht11/: demo_dht11_entry.c
    ../EXAMPLE/ds18b20/: demo_ds18b20_entry.c
    ../EXAMPLE/key/: demo_key_entry.c
    ../EXAMPLE/led_beep/: demo_led_beep_entry.c demo_rgb_led_entry.c
    ../EXAMPLE/ringbuf/: demo_ring_buf_entry.c
    ../EXAMPLE/soft_timer/: demo_soft_timer_entry.c
    ../EXAMPLE/timer/: demo_timer_entry.c
  group README
    ../: readme.txt
