# Keil uVision project ATK_BC28_NBIOT.uvprojx, settings and files
target ATK_BC28_NBIOT (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: NBIoT +hex
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\RTC;..\HARDWARE\RTC;..\HARDWARE\WKUP;..\HARDWARE\ADC;..\HARDWARE\DAC;..\HARDWARE\DMA;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\HARDWARE\SPI;..\HARDWARE\FLASH;..\HARDWARE\TOUCH;..\HARDWARE\REMOTE;..\HARDWARE\ADXL345;..\HARDWARE\DS18B20;..\HARDWARE\DHT11;..\EXAMPLE;..\HARDWARE\ATK-BC28;..\HARDWARE\NBIOT_UART;..\HARDWARE\GPS;..\ATK_RING_BUF;..\ATK_SOFT_TIMER;..\HARDWARE\TIMER;..\HARDWARE\RGB_LED
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/LED/: atk_led.c
    ../HARDWARE/KEY/: atk_key.c
    ../HARDWARE/NBIOT_UART/: atk_nbiot_usart.c
    ../HARDWARE/TIMER/: atk_timer.c
    ../HARDWARE/RGB_LED/: atk_rgb_led.c
  group SYSTEM
    ../SYSTEM/usart/: atk_usart.c
    ../SYSTEM/sys/: atk_sys.c
    ../SYSTEM/delay/: atk_delay.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_tim.c
  group ATKBC28
    ../HARDWARE/ATK-BC28/: atk_bc28.c atk_bc28_nbiot.c
  group SOFTTIMER
    ../ATK_SOFT_TIMER/: atk_soft_timer.c
  group RINGBUF
    ../ATK_RING_BUF/: atk_ring_buf.c
  group EXAMPLE
    ../EXAMPLE/atk_nbiot_bc28/: demo_bc28_gprs_attach_entry.c demo_bc28_info.c demo_bc28_huaweiiot_entry.c
    ../EXAMPLE/led_beep/: demo_led_beep_entry.c demo_rgb_led_entry.c
    ../EXAMPLE/dht11/: demo_dht11_entry.c
    ../EXAMPLE/key/: demo_key_entry.c
    ../EXAMPLE/uart/: demo_uart_any_data_len_recv_entry .c
    ../EXAMPLE/ringbuf/: demo_ring_buf_entry.c
    ../EXAMPLE/soft_timer/: demo_soft_timer_entry.c
  group README
    ../: README.TXT
