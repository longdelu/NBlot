# Keil uVision project ATK_BC28_NBIoT.uvprojx, settings and files
target ATK_BC28_NBIOT (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: NBIoT +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=6 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER, STM32H743xx
  c include: ..\CORE;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HALLIB\STM32H7xx_HAL_Driver\Inc;..\USMART;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\TIMER;..\HARDWARE\MPU;..\HARDWARE\LCD;..\HARDWARE\SDRAM;..\HARDWARE\24CXX;..\HARDWARE\IIC;..\HARDWARE\PCF8574;..\HARDWARE\QSPI;..\HARDWARE\W25QXX;..\HARDWARE\DHT11;..\HARDWARE\ATK-BC28;..\HARDWARE\AP3216C;..\HARDWARE\BEEP;..\HARDWARE\DS18B20;..\HARDWARE\RGB_LED;..\HARDWARE\NBIOT_UART;..\ATK_RING_BUF;..\ATK_SOFT_TIMER;..\EXAMPLE
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group USER
    ./: main.c stm32h7xx_it.c system_stm32h7xx.c stm32h7xx_hal_msp.c
  group CORE
    ../CORE/: core_cm7.h cmsis_armcc.h cmsis_compiler.h startup_stm32h743xx.s
  group SYSTEM
    ../SYSTEM/delay/: atk_delay.c
    ../SYSTEM/usart/: atk_usart.c
    ../SYSTEM/sys/: atk_sys.c
  group HALLIB
    ../HALLIB/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_sram.c stm32h7xx_hal_sdram.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_qspi.c stm32h7xx_hal_fdcan.c
  group HARDWARE
    ../HARDWARE/MPU/: mpu.c
    ../HARDWARE/SDRAM/: sdram.c
    ../HARDWARE/LCD/: lcd.c ltdc.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/PCF8574/: pcf8574.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/KEY/: atk_key.c
    ../HARDWARE/LED/: atk_led.c
    ../HARDWARE/TIMER/: atk_timer.c
    ../HARDWARE/AP3216C/: ap3216c.c
    ../HARDWARE/BEEP/: atk_beep.c
    ../HARDWARE/DS18B20/: ds18b20.c
    ../HARDWARE/NBIOT_UART/: atk_nbiot_usart.c
    ../HARDWARE/RGB_LED/: atk_rgb_led.c
  group ATKBC28
    ../HARDWARE/ATK-BC28/: atk_bc28.c atk_bc28_nbiot.c
  group USMART
    ../USMART/: usmart.c usmart_str.c usmart_config.c
  group RINGBUF
    ../ATK_RING_BUF/: atk_ring_buf.c
  group SOFTTIMER
    ../ATK_SOFT_TIMER/: atk_soft_timer.c
  group EXAMPLE
    ../EXAMPLE/ap3216c/: demo_ap3216c_entry.c
    ../EXAMPLE/atk_nbiot_bc28/: demo_bc28_low_power_entry.c demo_bc28_net_attach_entry.c demo_bc28_huaweiiot_entry.c demo_bc28_info.c
    ../EXAMPLE/dht11/: demo_dht11_entry.c
    ../EXAMPLE/ds18b20/: demo_ds18b20_entry.c
    ../EXAMPLE/key/: demo_key_entry.c
    ../EXAMPLE/led_beep/: demo_led_beep_entry.c demo_rgb_led_entry.c
    ../EXAMPLE/ringbuf/: demo_ring_buf_entry.c
    ../EXAMPLE/soft_timer/: demo_soft_timer_entry.c
    ../EXAMPLE/timer/: demo_timer_entry.c
  group README
    ../: readme.txt
