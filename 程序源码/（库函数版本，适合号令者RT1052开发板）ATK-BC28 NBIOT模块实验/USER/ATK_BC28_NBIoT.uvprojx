# Keil uVision project ATK_BC28_NBIoT.uvprojx, settings and files
target ram_debug (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: MIMXRT1052CVL5B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x00000000,0x020000) XRAM(0x20200000,0x040000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: NBIoT +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_MIMXRT1052CVL5B
  c misc: --library_interface=armcc --library_type=standardlib --diag_suppress=66,1296,186
  c include: ..\CORE;..\USER;..\FSLLIB;..\SYSTEM\delay;..\SYSTEM\lpuart;..\SYSTEM\sys;..\UTILITIES;..\UTILITIES\io;..\UTILITIES\log;..\UTILITIES\str;..\USMART;..\HARDWARE\KEY;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\SDRAM;..\HARDWARE\TEMPMON;..\HARDWARE\24CXX;..\HARDWARE\LPI2C;..\HARDWARE\PCF8574;..\HARDWARE\SPI;..\HARDWARE\W25QXX;..\HARDWARE\FLEXSPI;..\HARDWARE\RS485;..\HARDWARE\FLEXCAN;..\HARDWARE\REMOTE;..\HARDWARE\DHT11;..\EXAMPLE;..\ATK_SOFT_TIMER;..\ATK_RING_BUF;..\HARDWARE\ATK-BC28;..\HARDWARE\BEEP;..\HARDWARE\NBIOT_UART;..\HARDWARE\RGB_LED;..\HARDWARE\DS18B20;..\HARDWARE\AP3216C;..\HARDWARE\GPTIMER
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: ..\SCRIPT\rt1052_ram_scf.scf
  group USER
    ./: main.c system_MIMXRT1052.c
  group CORE
    ../CORE/: startup_MIMXRT1052.s
  group FSLLIB
    ../FSLLIB/: fsl_clock.c fsl_common.c fsl_gpio.c fsl_lpuart.c fsl_semc.c fsl_elcdif.c fsl_lpi2c.c fsl_lpspi.c fsl_flexcan.c fsl_gpt.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/lpuart/: lpuart.c
    ../SYSTEM/sys/: sys.c
  group HARDWARE
    ../HARDWARE/SDRAM/: sdram.c
    ../HARDWARE/LCD/: tftlcd.c elcdif.c
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/LPI2C/: lpi2c.c
    ../HARDWARE/SPI/: lpspi.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/PCF8574/: pcf8574.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/LED/: atk_led.c
    ../HARDWARE/RGB_LED/: atk_rgb_led.c
    ../HARDWARE/NBIOT_UART/: atk_nbiot_usart.c
    ../HARDWARE/BEEP/: atk_beep.c
    ../HARDWARE/KEY/: atk_key.c
    ../HARDWARE/GPTIMER/: gptimer.c
    ../HARDWARE/AP3216C/: ap3216c.c
    ../HARDWARE/DS18B20/: ds18b20.c
  group UTILITIES
    ../UTILITIES/io/: fsl_io.c
    ../UTILITIES/log/: fsl_log.c
    ../UTILITIES/str/: fsl_str.c
    ../UTILITIES/: fsl_assert.c fsl_debug_console.c fsl_notifier.c fsl_shell.c
  group ATKBC28
    ../HARDWARE/ATK-BC28/: atk_bc28.c atk_bc28_nbiot.c
  group SOFTTIMER
    ../ATK_SOFT_TIMER/: atk_soft_timer.c
  group RINGBUF
    ../ATK_RING_BUF/: atk_ring_buf.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group EXAMPLE
    ../EXAMPLE/ap3216c/: demo_ap3216c_entry.c
    ../EXAMPLE/atk_nbiot_bc28/: demo_bc28_info.c demo_bc28_low_power_entry.c demo_bc28_net_attach_entry.c demo_bc28_huaweiiot_entry.c
    ../EXAMPLE/dht11/: demo_dht11_entry.c
    ../EXAMPLE/ds18b20/: demo_ds18b20_entry.c
    ../EXAMPLE/key/: demo_key_entry.c
    ../EXAMPLE/led_beep/: demo_led_beep_entry.c demo_rgb_led_entry.c
    ../EXAMPLE/ringbuf/: demo_ring_buf_entry.c
    ../EXAMPLE/soft_timer/: demo_soft_timer_entry.c
    ../EXAMPLE/timer/: demo_timer_entry.c
  group README
    ../: readme.txt
target sdram_debug (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: MIMXRT1052CVL5B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: as above
  output: test
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DEBUG_IN_SDRAM,CPU_MIMXRT1052CVL5B
  c misc: as above
  c include: ..\CORE;..\USER;..\FSLLIB;..\SYSTEM\delay;..\SYSTEM\lpuart;..\SYSTEM\sys;..\UTILITIES;..\UTILITIES\io;..\UTILITIES\log;..\UTILITIES\str;..\USMART;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\SDRAM;..\HARDWARE\24CXX;..\HARDWARE\LPI2C;..\HARDWARE\PCF8574;..\HARDWARE\SPI;..\HARDWARE\W25QXX;..\HARDWARE\RS485;..\HARDWARE\FLEXCAN;..\HARDWARE\REMOTE;..\HARDWARE\DHT11;..\ATK_RING_BUF;..\ATK_SOFT_TIMER;..\EXAMPLE;..\HARDWARE\AP3216C;..\HARDWARE\ATK-BC28;..\HARDWARE\BEEP;..\HARDWARE\DS18B20;..\HARDWARE\GPTIMER;..\HARDWARE\NBIOT_UART;..\HARDWARE\RGB_LED
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: ..\SCRIPT\rt1052_sdram_scf.scf
target flexspi_debug_release (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: MIMXRT1052CVL5B NXP
  pack: NXP.MIMXRT1052_DFP.10.0.1
  cpu: as above
  output: test
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CPU_MIMXRT1052CVL5B
  c misc: as above
  c include: ..\CORE;..\USER;..\FSLLIB;..\SYSTEM\delay;..\SYSTEM\lpuart;..\SYSTEM\sys;..\UTILITIES;..\UTILITIES\io;..\UTILITIES\log;..\UTILITIES\str;..\USMART;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\SDRAM;..\HARDWARE\24CXX;..\HARDWARE\LPI2C;..\HARDWARE\PCF8574;..\HARDWARE\SPI;..\HARDWARE\W25QXX;..\HARDWARE\DS18B20;..\HARDWARE\DHT11;..\ATK_RING_BUF;..\ATK_SOFT_TIMER;..\EXAMPLE;..\HARDWARE\AP3216C;..\HARDWARE\ATK-BC28;..\HARDWARE\BEEP;..\HARDWARE\DS18B20;..\HARDWARE\GPTIMER;..\HARDWARE\NBIOT_UART;..\HARDWARE\RGB_LED;..\USER
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x0 size 0x20000
  scatter file: ..\SCRIPT\rt1052_flexspi_scf.scf
