# Keil uVision project ATK_BC28_NBIOT.uvprojx, settings and files
target ATK_BC28_NBIOT (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: NBIoT +hex
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: ..\CORE;..\OBJ;..\USER;..\HALLIB\STM32F4xx_HAL_Driver\Inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\KEY;..\HARDWARE\LCD;..\EXAMPLE\atk_nbiot_bc28;..\HARDWARE\NBIOT_UART;..\ATK_RING_BUF;..\EXAMPLE;..\ATK_SOFT_TIMER;..\HARDWARE\BC28;..\HARDWARE\TIMER;..\HARDWARE\PCF8574;..\HARDWARE\IIC;..\HARDWARE\DHT11;..\HARDWARE\SDRAM;..\HARDWARE\ATK-BC28;..\HARDWARE\RGB_LED;..\HARDWARE\BEEP;..\HARDWARE\AP3216C;..\HARDWARE\DS18B20
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group CORE
    ../CORE/: core_cm4.h cmsis_armcc.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32f429xx.s
  group HALLIB
    ../HALLIB/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_ll_fmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_sdram.c stm32f4xx_hal_ltdc.c
  group SYSTEM
    ../SYSTEM/delay/: atk_delay.c
    ../SYSTEM/sys/: atk_sys.c
    ../SYSTEM/usart/: atk_usart.c
  group HARDWARE
    ../HARDWARE/LED/: atk_led.c
    ../HARDWARE/LCD/: lcd.c ltdc.c
    ../HARDWARE/TIMER/: atk_timer.c
    ../HARDWARE/KEY/: atk_key.c
    ../HARDWARE/SDRAM/: sdram.c
    ../HARDWARE/NBIOT_UART/: atk_nbiot_usart.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/PCF8574/: pcf8574.c
    ../HARDWARE/RGB_LED/: atk_rgb_led.c
    ../HARDWARE/BEEP/: atk_beep.c
    ../HARDWARE/AP3216C/: ap3216c.c
    ../HARDWARE/DS18B20/: ds18b20.c
  group ATKBC28
    ../HARDWARE/ATK-BC28/: atk_bc28.c atk_bc28_nbiot.c
  group SOFTTIMER
    ../ATK_SOFT_TIMER/: atk_soft_timer.c
  group RINGBUF
    ../ATK_RING_BUF/: atk_ring_buf.c
  group EXAMPLE
    ../EXAMPLE/key/: demo_key_entry.c
    ../EXAMPLE/timer/: demo_timer_entry.c
    ../EXAMPLE/uart/: demo_uart_any_data_len_recv_entry .c
    ../EXAMPLE/soft_timer/: demo_soft_timer_entry.c
    ../EXAMPLE/ringbuf/: demo_ring_buf_entry.c
    ../EXAMPLE/atk_nbiot_bc28/: demo_bc28_net_attach_entry.c demo_bc28_info.c demo_bc28_huaweiiot_entry.c demo_bc28_low_power_entry.c
    ../EXAMPLE/dht11/: demo_dht11_entry.c
    ../EXAMPLE/led_beep/: demo_led_beep_entry.c demo_rgb_led_entry.c
    ../EXAMPLE/: demo_entry.h
    ../EXAMPLE/ap3216c/: demo_ap3216c_entry.c
    ../EXAMPLE/ds18b20/: demo_ds18b20_entry.c
  group README
    ../: readme.txt
