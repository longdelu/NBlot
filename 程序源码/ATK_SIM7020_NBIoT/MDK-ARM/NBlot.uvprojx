# Keil uVision project NBlot.uvprojx, settings and files
target NBlot (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32L476RCTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: NBlot +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L476xx
  c include: ../Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;..\HARDWARE\KEY;..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\NBLOT_UART;..\HARDWARE\TIMER;..\HARDWARE\LPTIMER;..\EXAMPLE;..\HARDWARE\SIM7020;..\ATK_SOFT_TIMER;..\EXAMPLE\sim7020;..\ATK_RING_BUF
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group Application/User
    ../Src/: main.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_lptim.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c
  group Drivers/CMSIS
    ..//Src/: system_stm32l4xx.c
  group HARDWARE
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/NBLOT_UART/: nblot_usart.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LPTIMER/: lptimer.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/SIM7020/: sim7020.c sim7020_nblot.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/sys/: sys.c
  group EXAMPLE
    ../EXAMPLE/key/: demo_key_entry.c
    ../EXAMPLE/led/: demo_led_entry.c
    ../EXAMPLE/: demo_entry.h
    ../EXAMPLE/nb_uart/: demo_uart_poll_entry.c demo_uart_int_entry.c demo_uart_any_data_len_recv_entry .c
    ../EXAMPLE/timer/: demo_timer_entry.c
    ../EXAMPLE/sim7020/: demo_sim7020_gprs_attach_entry.c demo_sim7020_info.c demo_sim7020_tcp_entry.c demo_sim7020_udp_entry.c demo_sim7020_coap_entry.c demo_sim7020_iot_entry.c demo_sim7020_low_power_entry.c demo_sim7020_easyiot_entry.c demo_sim7020_huaweiiot_entry.c
  group SOFTTIMER
    ../ATK_SOFT_TIMER/: atk_soft_timer.c atk_soft_timer_demo_entry.c
  group RING_BUF
    ../ATK_RING_BUF/: atk_ring_buf.c atk_ring_buf_demo_entry.c
software components: CMSIS:CORE 4.3.0
